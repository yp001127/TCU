# Keil uVision project FreeRTOS.uvprojx, settings and files
target TCU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TCU +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HardWare\ADC;..\HardWare\CAN;..\HardWare\GPIO;..\HardWare\IIC;..\HardWare\LED;..\HardWare\SENSOR;..\HardWare\SPI;..\HardWare\timer;..\HardWare\Data;..\USER;..\HardWare\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HardWare/LED/: led.c
    ../HardWare/timer/: timer.c
    ../HardWare/IIC/: IOIIC1.c IOIIC2.c IIC2.c IIC.c bsp_i2c.c
    ../HardWare/ADC/: adc.c
    ../HardWare/SPI/: SPI.c
    ../HardWare/CAN/: can.c
    ../HardWare/IWDG/: iwdg.c
    ../HardWare/freertos/: freertos.c
    ../HardWare/Data/: Process_DT.c
    ../HardWare/sensor/: Pressure.c Temp.c
    ../HardWare/SENSOR/: Pressure_BA.c HP5834_BA.c M1820B.c bsp_ina226.c
    ../HardWare/GPIO/: lighter.c
    ./: config.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
